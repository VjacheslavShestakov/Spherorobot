# Keil uVision project primer.uvproj, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: primer
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F30X,
  c include: .\Libraries\CMSIS\Device\ST\STM32F30x\Include;.\Libraries\STM32F30x_StdPeriph_Driver\inc;.\Utilities\STM32F3_Discovery;.\Libraries\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: startup_stm32f30x.s main.c system_stm32f30x.c
  group Periph
    ./Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_gpio.c stm32f30x_misc.c stm32f30x_rcc.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_exti.c stm32f30x_i2c.c stm32f30x_syscfg.c stm32f30x_spi.c
